# Keil uVision project meter.uvprojx, settings and files
target stm32f107-lwip (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: meter +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\src;..\src\App;..\src\BSP;..\src\dev;..\src\STM32Lib;..\src\ETHLib\inc;..\src\LwIP\port;..\src\LwIP\port\arch;..\src\UCOSII;..\src\LwIP\src\include;..\src\LwIP\src\include\ipv4;..\src\LwIP\src\include\ipv4\lwip;..\src\LwIP\src\include\lwip;..\src\LwIP\src\include\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USR
    ../src/: main.c stm32f10x_it.c tcpserver.c
    ../src/BSP/: BSP.c
    ../src/App/: app.c
    ../src/LwIP/port/: LwIP.c
    ../src/dev/: devTcpSvr.c
  group STM32Lib
    ../src/STM32Lib/: core_cm3.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group ETHLib
    ../src/ETHLib/src/: stm32_eth.c
  group STARTUP
    ../src/STM32Lib/StartUp/: startup_stm32f10x_cl.s
  group UCOS
    ../src/UCOSII/: os_core.c os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSport
    ../src/UCOSII/: os_cpu_a.asm os_cfg.h
  group LWIP
    ../src/LwIP/port/: ethernetif.c sys_arch.c
    ../src/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../src/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../src/LwIP/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../src/LwIP/src/netif/: etharp.c
software components: CMSIS:CORE 5.1.2
